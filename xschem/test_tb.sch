v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 450 -830 450 -800 { lab=#net1}
N 320 -840 320 -810 { lab=io_analog[4]}
N 590 -290 590 -270 { lab=io_analog[7]}
N 590 -290 650 -290 { lab=io_analog[7]}
N 390 -120 390 -80 { lab=GND}
N 590 -120 590 -80 { lab=GND}
N 550 -120 550 -100 { lab=GND}
N 550 -100 590 -100 { lab=GND}
N 550 -200 550 -180 { lab=io_analog[7]}
N 550 -200 590 -200 { lab=io_analog[7]}
N 430 -200 430 -180 { lab=io_analog[8]}
N 390 -200 430 -200 { lab=io_analog[8]}
N 430 -120 430 -100 { lab=GND}
N 390 -100 430 -100 { lab=GND}
N 390 -240 390 -180 { lab=io_analog[8]}
N 590 -240 590 -180 { lab=io_analog[7]}
N 390 -270 390 -240 { lab=io_analog[8]}
N 590 -270 590 -240 { lab=io_analog[7]}
N 200 -840 200 -810 { lab=io_analog[3]}
N 200 -610 220 -610 { lab=io_analog[6]}
N 280 -610 310 -610 { lab=io_analog[2]}
N 200 -530 220 -530 { lab=io_analog[6]}
N 280 -530 310 -530 { lab=io_analog[1]}
N 200 -450 220 -450 { lab=io_analog[6]}
N 280 -450 310 -450 { lab=io_analog[0]}
N 1040 -350 1210 -350 { lab=io_analog[9]}
N 1040 -290 1210 -290 { lab=io_analog[10]}
N 1120 -290 1120 -270 { lab=io_analog[10]}
N 1120 -370 1120 -350 { lab=io_analog[9]}
N 650 -290 740 -290 { lab=io_analog[7]}
N 390 -350 390 -270 { lab=io_analog[8]}
N 390 -350 740 -350 { lab=io_analog[8]}
N 680 -900 740 -900 { lab=#net2}
N 680 -880 740 -880 { lab=#net3}
N 680 -860 740 -860 { lab=#net4}
N 680 -840 740 -840 { lab=#net5}
N 680 -820 740 -820 { lab=#net6}
N 680 -800 740 -800 { lab=#net7}
N 680 -780 740 -780 { lab=#net8}
N 680 -760 740 -760 { lab=#net9}
N 680 -740 740 -740 { lab=#net10}
N 680 -720 740 -720 { lab=#net11}
N 680 -700 740 -700 { lab=#net12}
N 680 -680 740 -680 { lab=#net13}
N 680 -660 740 -660 { lab=#net14}
N 1040 -900 1100 -900 { lab=#net15}
N 1040 -880 1100 -880 { lab=#net16}
N 1040 -860 1100 -860 { lab=#net17}
N 1040 -840 1100 -840 { lab=#net18}
N 1040 -820 1100 -820 { lab=#net19}
N 1040 -800 1100 -800 { lab=#net20}
N 1040 -780 1100 -780 { lab=#net21}
N 1040 -760 1100 -760 { lab=#net22}
N 1040 -740 1100 -740 { lab=#net23}
N 1040 -720 1100 -720 { lab=#net24}
N 1040 -700 1100 -700 { lab=#net25}
N 1040 -680 1100 -680 { lab=#net26}
N 1040 -660 1100 -660 { lab=#net27}
N 1040 -640 1100 -640 { lab=#net28}
N 1040 -620 1100 -620 { lab=#net29}
N 1040 -540 1100 -540 { lab=#net30}
N 1040 -600 1100 -600 { lab=io_analog[10:0]}
N 1100 -600 1150 -600 { lab=io_analog[10:0]}
N 1150 -630 1150 -600 { lab=io_analog[10:0]}
N 1150 -680 1150 -630 { lab=io_analog[10:0]}
N 1150 -680 1240 -680 { lab=io_analog[10:0]}
N 1150 -700 1240 -700 { lab=io_analog[10:0]}
N 1150 -720 1240 -720 { lab=io_analog[10:0]}
N 1150 -740 1240 -740 { lab=io_analog[10:0]}
N 1150 -760 1240 -760 { lab=io_analog[10:0]}
N 1150 -780 1240 -780 { lab=io_analog[10:0]}
N 1150 -800 1240 -800 { lab=io_analog[10:0]}
N 1150 -820 1240 -820 { lab=io_analog[10:0]}
N 1150 -840 1240 -840 { lab=io_analog[10:0]}
N 1150 -860 1240 -860 { lab=io_analog[10:0]}
N 1150 -880 1240 -880 { lab=io_analog[10:0]}
N 1150 -880 1150 -680 { lab=io_analog[10:0]}
N 1250 -690 1430 -690 { lab=io_analog[0]}
N 1250 -710 1430 -710 { lab=io_analog[1]}
N 1250 -730 1430 -730 { lab=io_analog[2]}
N 1250 -750 1430 -750 { lab=io_analog[3]}
N 1250 -770 1430 -770 { lab=io_analog[4]}
N 1250 -790 1430 -790 { lab=io_analog[5]}
N 1250 -810 1430 -810 { lab=io_analog[6]}
N 1250 -830 1430 -830 { lab=io_analog[7]}
N 1250 -850 1430 -850 { lab=io_analog[8]}
N 1250 -870 1430 -870 { lab=io_analog[9]}
N 1250 -890 1430 -890 { lab=io_analog[10]}
N 1040 -560 1100 -560 { lab=#net31}
N 1040 -580 1100 -580 { lab=#net32}
C {devices/vsource.sym} 450 -770 0 0 {name=VDD_source value=1.8}
C {devices/gnd.sym} 390 -80 0 1 {name=l3 lab=GND}
C {devices/code.sym} -190 -360 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/nonfet.spice
* Mismatch parameters
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
*.include \\\\$::SKYWATER_MODELS\\\\/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice
* Resistor\\\\$::SKYWATER_MODELS\\\\/Capacitor
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical.spice
.include \\\\$::SKYWATER_MODELS\\\\/models/r+c/res_typical__cap_typical__lin.spice
* Special cells
*.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/specialized_cells.spice
* All models
.include \\\\$::SKYWATER_MODELS\\\\/models/all.spice
* Corner
*.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt/rf.spice
*.include /home/jared/Documents/GS_Design/tia_post_approval/pex/top_pex_fixed.spice
"}
C {devices/launcher.sym} 840 -430 0 0 {name=h1
descr='tate
tclcommand="ngspice::annotate"}
C {devices/ngspice_probe.sym} 450 -810 0 0 {name=r1}
C {devices/ammeter.sym} 450 -860 2 0 {name=Vmeas current=3.1385e-04}
C {devices/code.sym} -190 -200 0 0 {name=SAVE_PARAMS
only_toplevel=false

value=".option savecurrents
.control
save all 
op
write test_tb.raw
.endc"
}
C {devices/code_shown.sym} -240 20 0 0 {name=SPICE
only_toplevel=false

value=".control
*tran .01n 50n 1n

*tran 10u 5m
*plot Vout_n
*plot Vcmfb 
*plot Vcm1

*ac dec 50 1k 10G
*plot vdb(\\"io_analog[9]\\")
*plot vdb(Vcm1)
*plot vp(Vcm1)*57.296

*exit
.endc
"

*value=".control
set sqrnoise

*noise v(Vout_n) IINN_source dec 10 1 10000T
*noise v(Vout_n) IINN_source dec 50 1 100G
noise v(Vout_p) IINN_source dec 10 20k 1g
*setplot noise1
*plot loglog onoise_spectrum

setplot noise2
print onoise_total 
*exit
.endc
"}
C {devices/vsource.sym} 320 -780 0 0 {name=Vb2_source value=".75"}
C {devices/gnd.sym} 590 -80 0 0 {name=l18 lab=GND}
C {devices/capa.sym} 620 -240 3 1 {name=C3
m=1
value=6p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 650 -240 3 1 {name=l50 lab=GND}
C {devices/capa.sym} 360 -240 1 0 {name=C4
m=1
value=6p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 330 -240 1 0 {name=l51 lab=GND}
C {devices/isource.sym} 390 -150 0 1 {name=IINP_source
value="ac 1 0"
*value="sin(0,50n,1k)"
*value="pulse(0,450n,1n,0,0,1,10) ac 1 0"}
C {devices/isource.sym} 590 -150 0 0 {name=IINN_source 
value="ac -1 0"
*value="sin(0,-50n,1k)"
*value="pulse(0,-450n,1n,0,0,1,10)"}
C {devices/capa.sym} 1120 -240 2 0 {name=C5
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1120 -210 0 0 {name=l78 lab=GND}
C {devices/capa.sym} 1120 -400 0 0 {name=C6
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1120 -430 2 0 {name=l80 lab=GND}
C {devices/res_ac.sym} 430 -150 0 0 {name=R7
value=100meg
ac=100meg
m=1}
C {devices/res_ac.sym} 550 -150 0 1 {name=R8
value=100meg
ac=100meg
m=1}
C {devices/vsource.sym} 200 -780 0 0 {name=Vb5 value="1.3"}
C {devices/res_ac.sym} 250 -610 3 0 {name=R2
value=26k
ac=26k
m=1}
C {devices/res_ac.sym} 250 -530 3 0 {name=R11
value=26k
ac=26k
m=1}
C {devices/res_ac.sym} 250 -450 3 0 {name=R1
value=26k
ac=26k
m=1}
C {devices/lab_wire.sym} 650 -350 0 1 {name=l19 sig_type=std_logic lab=io_analog[8]}
C {devices/lab_wire.sym} 650 -290 0 1 {name=l21 sig_type=std_logic lab=io_analog[7]}
C {user_analog_project_wrapper.sym} 890 -720 0 0 {name=x2}
C {devices/lab_pin.sym} 200 -840 1 0 {name=l22 sig_type=std_logic lab=io_analog[3]}
C {devices/lab_pin.sym} 1210 -350 0 1 {name=l27 sig_type=std_logic lab=io_analog[9]}
C {devices/lab_pin.sym} 1210 -290 0 1 {name=l28 sig_type=std_logic lab=io_analog[10]}
C {devices/lab_pin.sym} 310 -450 2 0 {name=l29 sig_type=std_logic lab=io_analog[0]}
C {devices/lab_pin.sym} 310 -530 2 0 {name=l30 sig_type=std_logic lab=io_analog[1]}
C {devices/lab_pin.sym} 310 -610 2 0 {name=l31 sig_type=std_logic lab=io_analog[2]}
C {devices/lab_pin.sym} 320 -840 1 0 {name=l33 sig_type=std_logic lab=io_analog[4]}
C {devices/lab_pin.sym} 450 -890 2 0 {name=l16 sig_type=std_logic lab=io_analog[6]}
C {devices/lab_pin.sym} 1150 -630 2 0 {name=l2 sig_type=std_logic lab=io_analog[10:0]}
C {devices/gnd.sym} 320 -750 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 200 -750 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 20 -870 2 0 {name=l12 sig_type=std_logic lab=io_analog[5]}
C {devices/gnd.sym} 20 -810 0 0 {name=l13 lab=GND}
C {devices/gnd.sym} 450 -740 0 0 {name=l14 lab=GND}
C {devices/bus_connect.sym} 1240 -680 1 1 {name=l15 lab=io_analog[0]}
C {devices/bus_connect.sym} 1240 -700 1 1 {name=l17 lab=io_analog[1]}
C {devices/bus_connect.sym} 1240 -720 1 1 {name=l23 lab=io_analog[2]}
C {devices/bus_connect.sym} 1240 -740 1 1 {name=l24 lab=io_analog[3]}
C {devices/bus_connect.sym} 1240 -760 1 1 {name=l25 lab=io_analog[4]}
C {devices/bus_connect.sym} 1240 -780 1 1 {name=l26 lab=io_analog[5]}
C {devices/bus_connect.sym} 1240 -800 1 1 {name=l32 lab=io_analog[6]}
C {devices/bus_connect.sym} 1240 -820 1 1 {name=l34 lab=io_analog[7]}
C {devices/bus_connect.sym} 1240 -840 1 1 {name=l35 lab=io_analog[8]}
C {devices/bus_connect.sym} 1240 -860 1 1 {name=l36 lab=io_analog[9]}
C {devices/bus_connect.sym} 1240 -880 1 1 {name=l37 lab=io_analog[10]}
C {devices/lab_pin.sym} 1430 -690 2 0 {name=l40 sig_type=std_logic lab=io_analog[0]}
C {devices/lab_pin.sym} 1430 -710 2 0 {name=l42 sig_type=std_logic lab=io_analog[1]}
C {devices/lab_pin.sym} 1430 -730 2 0 {name=l43 sig_type=std_logic lab=io_analog[2]}
C {devices/lab_pin.sym} 1430 -750 2 0 {name=l44 sig_type=std_logic lab=io_analog[3]}
C {devices/lab_pin.sym} 1430 -770 2 0 {name=l45 sig_type=std_logic lab=io_analog[4]}
C {devices/lab_pin.sym} 1430 -790 2 0 {name=l46 sig_type=std_logic lab=io_analog[5]}
C {devices/lab_pin.sym} 1430 -810 2 0 {name=l47 sig_type=std_logic lab=io_analog[6]}
C {devices/lab_pin.sym} 1430 -830 2 0 {name=l48 sig_type=std_logic lab=io_analog[7]}
C {devices/lab_pin.sym} 1430 -850 2 0 {name=l49 sig_type=std_logic lab=io_analog[8]}
C {devices/lab_pin.sym} 1430 -870 2 0 {name=l52 sig_type=std_logic lab=io_analog[9]}
C {devices/lab_pin.sym} 1430 -890 2 0 {name=l53 sig_type=std_logic lab=io_analog[10]}
C {devices/ngspice_get_value.sym} 570 80 0 1 {name=r9 node=v(io_analog[6])
descr="V[6]="}
C {devices/ngspice_get_value.sym} 1630 -730 0 1 {name=r10 node=v(io_analog[6])
descr="V[6]="}
C {devices/ngspice_get_value.sym} 1630 -760 0 1 {name=r11 node=v(io_analog[7])
descr="V[7]="}
C {devices/ngspice_get_value.sym} 1630 -790 0 1 {name=r12 node=v(io_analog[8])
descr="V[8]="}
C {devices/ngspice_get_value.sym} 1630 -820 0 1 {name=r13 node=v(io_analog[9])
descr="V[9]="}
C {devices/ngspice_get_value.sym} 1630 -850 0 1 {name=r14 node=v(io_analog[10])
descr="V[10]="}
C {devices/ngspice_get_value.sym} 1630 -700 0 1 {name=r15 node=v(io_analog[5])
descr="V[5]="}
C {devices/ngspice_get_value.sym} 1730 -850 0 1 {name=r16 node=v(io_analog[4])
descr="V[4]="}
C {devices/ngspice_get_value.sym} 1730 -820 0 1 {name=r17 node=v(io_analog[3])
descr="V[3]="}
C {devices/ngspice_get_value.sym} 1730 -790 0 1 {name=r18 node=v(io_analog[2])
descr="V[2]="}
C {devices/ngspice_get_value.sym} 1730 -760 0 1 {name=r19 node=v(io_analog[1])
descr="V[1]="}
C {devices/ngspice_get_value.sym} 1730 -730 0 1 {name=r20 node=v(io_analog[0])
descr="V[0]="}
C {devices/vsource.sym} 20 -840 0 0 {name=VDD_source1 value=0}
C {devices/lab_pin.sym} 200 -610 0 0 {name=l4 sig_type=std_logic lab=io_analog[6]}
C {devices/lab_pin.sym} 200 -530 0 0 {name=l5 sig_type=std_logic lab=io_analog[6]}
C {devices/lab_pin.sym} 200 -450 0 0 {name=l6 sig_type=std_logic lab=io_analog[6]}
