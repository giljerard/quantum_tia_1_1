v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/res_generic_po.sym} 210 -50 3 0 {name=R1
W=2.85
L=8.55
model=res_generic_po
spiceprefix=X
mult=1}
C {devices/iopin.sym} 30 -50 0 0 {name=p2 lab=out}
C {devices/iopin.sym} 30 -80 0 0 {name=p4 lab=in}
C {devices/lab_pin.sym} 180 -50 2 1 {name=l2 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} 240 -50 2 0 {name=l6 sig_type=std_logic lab=out}
