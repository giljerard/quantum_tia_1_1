* NGSPICE file created from sf.ext - technology: sky130A

.subckt sf_half Vout g_u g_d GND VDD
X0 Vout g_u VDD Vout sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2.5e+07u l=320000u M=26
X1 Vout g_d GND VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.5e+07u l=450000u M=26
.ends

.subckt sf VDD Vin_n Vin_p Vout_n GND
Xsf_half_0 Vout_n Vin_p sf_half_1/g_d GND VDD sf_half
Xsf_half_1 Vout_n Vin_n sf_half_1/g_d GND VDD sf_half
.ends
