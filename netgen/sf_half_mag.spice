* NGSPICE file created from sf_half.ext - technology: sky130A

.subckt sf_half Vout g_u g_d GND VDD
X0 Vout g_u VDD Vout sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2.5e+07u l=320000u M=26
X1 GND g_d Vout VSUBS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.5e+07u l=450000u M=26
.ends
