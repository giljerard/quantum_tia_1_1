* NGSPICE file created from sf_half.ext - technology: sky130A

.subckt sf_half g_u g_d VDD Vout GND
X0 VDD g_u Vout Vout sky130_fd_pr__nfet_01v8_lvt ad=2.1445e+14p pd=8.708e+08u as=3.3575e+14p ps=1.37686e+09u w=2.5e+07u l=320000u M=26
X1 GND g_d Vout GND sky130_fd_pr__nfet_01v8 ad=1.725e+14p pd=7.138e+08u as=0p ps=0u w=2.5e+07u l=450000u M=26
.ends
